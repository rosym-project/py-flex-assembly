Commit message: update wiping

File: gym_flexassembly/data/visualization/frame_full.urdf (robot description, URDF)
Before this commit: robot frame, 7 links, 6 joints
Links:
- link base: geometry visual sphere radius=0.1
