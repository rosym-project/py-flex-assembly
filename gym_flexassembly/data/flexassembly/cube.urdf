Commit message: update models

File: gym_flexassembly/data/flexassembly/cube.urdf (robot description, URDF)
Before this commit: robot simple_cube, 1 links, 0 joints
Links:
- link cube: geometry collision box size=0.1 0.42 0.2; visual box size=0.1 0.35 0.2
