Commit message: added tests

File: gym_flexassembly/data/flexassembly/cube_long.urdf (robot description, URDF)
Before this commit: robot simple_cube, 1 links, 0 joints
Links:
- removed link cube
- added link cube_long, mass 1.0; collision box size=0.1 0.35 0.2; visual box size=0.1 0.35 0.2
